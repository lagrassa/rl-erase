Commit message: variable grasps incorporated into training

File: cup_skills/urdf/cup/cup_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 15.5 -> 3.5
